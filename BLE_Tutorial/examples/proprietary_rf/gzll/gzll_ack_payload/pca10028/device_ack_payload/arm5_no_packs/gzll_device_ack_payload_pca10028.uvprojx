# Keil uVision project gzll_device_ack_payload_pca10028.uvprojx, settings and files
target nrf51422_xxac (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10028 BSP_DEFINES_ONLY GAZELL_PRESENT NRF51
  c include: ..\..\..\config;..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\properitary_rf\gzll;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\bsp
  asm define: BOARD_PCA10028 BSP_DEFINES_ONLY GAZELL_PRESENT NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main_device_ack_payload.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
  group nRF_Properitary_RF
    ../../../../../../../components/properitary_rf/gzll/arm/: gzll_arm.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
